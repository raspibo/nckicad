# Repository raspibo/nckicad

File README.md:

# nckicad
Raccolta di informazioni, progetti Kicad, utilizzata durante il non-corso Kicad di Raspibo.

## KiCad design esempi/04_motor_driver_LD293D/04_motor_driver_L293D.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8: D; sod123
IC1: L293D; dil_16-300
J1: Arduino_Nano_Header; arduino_nano_header
P1: OUT12; pin_strip_2
P2: ALIM_HALL; pin_strip_6
P3: CONN_MOT1; pin_strip_5
P4: OUT34; pin_strip_2
P5: HALL_01; pin_strip_2mm_3
P6: HOLE1; hole_3mm5
P7: HOLE2; hole_3mm5
P8: HALL_02; pin_strip_2mm_3
P9: ING5V; pin_strip_2
P10: SER; pin_strip_3
P11: EXT_MOT; pin_strip_5
Q1, Q2: Q_NPN_BCE; to92_3
R1, R2, R3, R4: R; r_0805

Connections:
1,2DIR: IC1.2 (1A), J1.7 (D4/T0), P3.3, R1.1
1,2EN: IC1.1 (1,2EN), J1.12 (D9/0C1), P3.5; also elsewhere on the board
3,4DIR: IC1.15 (4A), J1.8 (D5/T1), P3.2, R4.1
3,4EN: IC1.9 (3,4EN), J1.13 (D10/SS), P3.4; also elsewhere on the board
+5V: IC1.16 (VCC1), J1.27 (5V), P2.4, P5.1, P8.1, P9.2, R2.1, R3.1
/BASE-1: Q1.1 (B), R1.2
/BASE-2: Q2.1 (B), R4.2
/COLL: IC1.10 (3A), Q2.2 (C), R3.2
/COLL-1: IC1.7 (2A), Q1.2 (C), R2.2
GND: D2.2 (A), D4.2 (A), D6.2 (A), D8.2 (A), IC1.4 (GND1), IC1.5 (GND2), IC1.12 (GND4), IC1.13 (GND3), J1.29 (GND), P2.1, P2.2, P3.1, P5.2, P8.2, P9.1, P11.1, Q1.3 (E), Q2.3 (E); also elsewhere on the board
unnamed: D1.2 (A), D2.1 (K), IC1.6 (2Y), P1.1
unnamed: D3.2 (A), D4.1 (K), IC1.3 (1Y), P1.2
unnamed: D5.2 (A), D6.1 (K), IC1.14 (4Y), P4.2
unnamed: D7.2 (A), D8.1 (K), IC1.11 (3Y), P4.1
unnamed: J1.1 (D1/TX), P10.3
unnamed: J1.2 (D0/RX), P10.2
unnamed: J1.4 (GND), P10.1
unnamed: J1.6 (D3/INT1), P11.3
unnamed: J1.10 (D7/AIN1), P11.4
unnamed: J1.11 (D8/ICP), P11.5
unnamed: J1.14 (D11/MOSI), P11.2
unnamed: J1.19 (A0), P2.5, P5.3
unnamed: J1.20 (A1), P2.6, P8.3
VCC: D1.1 (K), D3.1 (K), D5.1 (K), D7.1 (K), IC1.8 (VCC2), P2.3

Board: 2 copper layers, 63.5 x 24.1 mm, 29 parts (14 on the bottom side), 24 nets.

Other parts of the board:
R5, R6: R; r_0805

Their connections:
1,2EN: R5.1; also elsewhere on the board
3,4EN: R6.1; also elsewhere on the board
GND: R5.2, R6.2; also elsewhere on the board

File esempi/10_3V3_keychain/bom/bom_pcb.csv:

Item,Reference(s),Value,Quantity
1,D1 D2 D3 D4 D5,LED,5
2,IC1,ATTINY85-S,1
3,P1,USB_OTG,1
4,P2 P3 P4 P5 P6 P7 P8 P9,CONN_01X01,8
5,R1 R2 R3 R4 R5,R,5

## KiCad design esempi/09_raspibo_gadget/09_raspibo_gadget.kicad_pcb

Parts:
D1, D2, D3, D4, D5: LED; Led_0805
IC1: ATTINY85-S; SOIC-8-N
P1: USB_OTG; conn_usb_B_micro_smd
P3, P4, P5, P6, P7, P10: CONN_01X01; hole_1mm
P8: CONN_01X01; contorno
P9: CONN_01X01; raspibo_logo
R1, R2, R3, R4, R5: R; r_0805

Connections:
/MISO: D2.2 (A), IC1.6 (PB1(MISO/DO/AIN1/OC0B/OC1A/PCINT1)), P6.1
/MOSI: D1.2 (A), IC1.5 (PB0(MOSI/DI/SDA/AIN0/OC0A/OC1A/AREF/PCI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), P5.1
/RESET: IC1.1 (PB5(~RESET~/dW/ADC0/PCINT5)), P10.1
/SCK: D3.2 (A), IC1.7 (PB2(SCK/USCK/SCL/T0/INT0/ADC1/PCINT2)), P4.1
GND: IC1.4 (GND), P1.5 (GND), P3.1, R1.1, R2.1, R3.1, R4.1, R5.1; also elsewhere on the board
unnamed: D1.1 (K), R1.2
unnamed: D2.1 (K), R2.2
unnamed: D3.1 (K), R3.2
unnamed: D4.1 (K), R4.2
unnamed: D4.2 (A), IC1.2 (PB3(XTAL1/CLKI/OC1B/ADC3/PCINT3))
unnamed: D5.1 (K), R5.2
unnamed: D5.2 (A), IC1.3 (PB4(XTAL2/CLKO/OC1B/ADC2/PCINT4))
VCC: IC1.8 (VCC), P1.1 (VCC), P7.1; also elsewhere on the board

Board: 2 copper layers, 25.4 x 25.4 mm, 25 parts (1 on the bottom side), 13 nets.

Other parts of the board:
P2, P3#2, P3#3, P7#2: CONN_01X01; hole_1mm
hole_2mm: VAL**; hole_2mm

Their connections:
GND: P3#2.1, P3#3.1; also elsewhere on the board
VCC: P7#2.1; also elsewhere on the board

## KiCad design esempi/11_ESP12_adapter/ESP-012_adapter.kicad_pcb

Board: 2 copper layers, 38.1 x 31.8 mm, 8 parts (0 on the bottom side), 14 nets.

Parts:
C1, C2: C; C_0805_HandSoldering
P1, P2: CONN_01X08; Pin_Header_Straight_1x08
P3, P4: CONN_01X01; Pin_Header_Straight_1x01
U1: ESP-12
U2: AP1117D33; SOT-223

Connections:
/3.3V: C2.1, P1.1, P1.3, P1.6, U1.3, U1.6, U1.8, U2.2
unnamed: C1.1, P3.1, U2.3
unnamed: C1.2, C2.2, P2.7, P2.8, P4.1, U1.9, U1.10, U2.1
unnamed: P1.2, U1.7
unnamed: P1.4, U1.5
unnamed: P1.5, U1.4
unnamed: P1.7, U1.2
unnamed: P1.8, U1.1
unnamed: P2.1, U1.16
unnamed: P2.2, U1.15
unnamed: P2.3, U1.14
unnamed: P2.4, U1.13
unnamed: P2.5, U1.12
unnamed: P2.6, U1.11

## KiCad design esempi/08_arduino_shield/senzanome.kicad_pcb

Board: 2 copper layers, 7 parts (0 on the bottom side), 10 nets.

Parts:
J1: Arduino_Header; arduino_header
L1, L2, L3, L4: INDUCTOR_SMALL; mors_2p
P1: CONN_01X02; mors_2p
U1: ULN2803; dil_18-300

Connections:
GND: J1.7, P1.2, U1.9
unnamed: J1.20, U1.7, U1.8
unnamed: J1.21, U1.5, U1.6
unnamed: J1.24, U1.3, U1.4
unnamed: J1.26, U1.1, U1.2
unnamed: L1.2, U1.17, U1.18
unnamed: L2.2, U1.15, U1.16
unnamed: L3.2, U1.13, U1.14
unnamed: L4.2, U1.11, U1.12
VCC: L1.1, L2.1, L3.1, L4.1, P1.1, U1.10

File esempi/08_arduino_shield/bom/bom_pcb.csv:

Item,Reference(s),Value,Quantity
1,J1,Arduino_Header,1
2,L1 L2 L3 L4,INDUCTOR_SMALL,4
3,U1,ULN2803,1

## KiCad design esempi/01_led/01_led.kicad_pcb

Board: 2 copper layers, 3 parts (0 on the bottom side), 3 nets.

Parts:
D1: LED; LED-5MM
P1: CONN_01X02; Pin_Header_Straight_1x02
R1: R; Resistor_Horizontal_RM10mm

Connections:
GND: D1.2, P1.1
unnamed: D1.1, R1.2
VCC: P1.2, R1.1

## KiCad design esempi/05_arduino_minimal/senzanome.kicad_pcb

Board: 2 copper layers, 50.8 x 21.6 mm, 8 parts (0 on the bottom side), 8 nets, no tracks yet.

Parts:
10K1: R; RC03
16mHz1: Crystal; crystal_hc-49u
22pF1, 22pF2: C; cnp_3mm_disc
100nF1: C; cnp_7.5mm_disc
IC1: ATMEGA328P-P; dil_28-300
P1: CONN_01X05; pin_strip_3-90
SW1: RESET; PCB_PUSH

Connections:
GND: 22pF1.1, 22pF2.1, IC1.8, IC1.22, SW1.2
unnamed: 16mHz1.1, 22pF1.2, IC1.9
unnamed: 16mHz1.2, 22pF2.2, IC1.10
unnamed: 100nF1.1, P1.1
unnamed: 10K1.2, 100nF1.2, SW1.1
unnamed: IC1.2, P1.2
unnamed: IC1.3, P1.3
VCC: 10K1.1, IC1.7, IC1.20

## Commit log

2015-04-20 Aggiunti files esempio, commit iniziale
2015-05-03 Aggiunti esempi nuovo componente, arduino shield, modoficato motor driver
2015-05-04 Creato script per merge pdf files in footprints_doc folder and create footprints.pdf
2015-05-04 Modifiche ad arduino shield per connettori più piccoli
2015-05-06 sistemato circuito L293D
2015-05-06 sistemato circuito L293D aggiunti 2 diodi mancanti
2015-05-26 Creato script che modifica la largehzza piste sulla board
2015-05-26 Aggiunti due script per nascondere serigrafie e modificare dimensione fori
2015-06-23 Modifiche alla board per uso su motori recuperati da macchinetta caffe
2015-06-23 Modifiche scheda per uso con motori di recupero da macchine caffe
2015-06-25 Aggiunti connettori e corrette connessioni a pin pwm
2015-06-25 Versione spedita in stampa e aggiunte viste 3D
2015-07-12 Creato portachiavi gadget raspibo logo
2015-07-12 Piccola modifica su pcb raspibo logo, spostata scritta, era troppo vicina ai led
2015-08-10 Modifiche a Raspibo gadget e L293D
2015-11-07 Allineamento files per pubblicazione su wiki
2015-12-16 Modifiche a file ponte H eagginto adapter ESP012
